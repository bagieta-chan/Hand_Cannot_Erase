<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Thesis_glove.ewp</path>
  </project>
  <batchBuild />
</workspace>
